# Keil uVision project chicken-temp-monitor.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: chicken-temp-monitor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c I2C.c I2C.h UTIL.c UTIL.h USART.c USART.h ESP.c ESP.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, Device:Startup 2.6.3
